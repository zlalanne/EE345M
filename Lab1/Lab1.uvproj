# Keil uVision project Lab1.uvproj, settings and files
target Lab1 (ARM-ADS)
  device: LM3S8962 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Lab1
  c flags: Optim=1
  c include: ../../.
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Code
    ./: Startup.s Lab1.c Output.c Output.h rit128x96x4.c rit128x96x4.h
  group Driver Library
    ../../driverlib/rvmdk/: driverlib.lib
